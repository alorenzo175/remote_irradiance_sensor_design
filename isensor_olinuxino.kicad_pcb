# Repository alorenzo175/remote_irradiance_sensor_design

File README.md:

# Remote Irradiance Sensors

This repositories contains the circuit board design for sensors that are
deployed remotely, communicate in real-time via a cellular data network,
and are power by a solar panel. The sensors were designed to specifically
measure irradiance to support short term forecasting [1,2].

[1] A. T. Lorenzo, W. F. Holmgren, and A. D. Cronin, “Irradiance forecasts based
    on an irradiance monitoring network , cloud motion , and spatial averaging,”
    Sol. Energy, vol. 122, pp. 1158–1169, 2015.

[2] A. T. Lorenzo, M. Morzfeld, W. F. Holmgren, and A. D. Cronin,
    “Optimal interpolation of satellite and ground data for irradiance
    nowcasting at city scales,” Sol. Energy, vol. 144, pp. 466–474, 2017.

## KiCad design isensor_olinuxino.kicad_pcb

Parts:
C1, C2: 4.7 uF; C1
C3: 100 nF; C2
C4: 10 nF; C1
C5: 68 uF; C1V7
C6, C8, C9, C10, C11: 1uF; C1
C7: 330pF; C1
C12: 0.1uF; C2
C13: 10uF; C1
D1: SR305; D4
J1: USB; USB_B
K1: CONN_3; BARREL_JACK
L1: 100 uH; L15-E
P1, P2: CONN_2; SIL-2
P3: CONN_2; PINHEAD1-2
P4, P5, P6, P7: CONN_1
R1: 50k; R1
R2: 20k; R1
R4: 680; R1
U1: LM2676; TO220-7
U2: LM61
U3: MCP602; DIP-8__300
U4: MCP1541; TO92
U5: MCP3201; DIP-8__300
U6: MCP3204; DIP-14__300
U7: OLINXUINO_I.MX223; Olinuxino_i.MX223
U8: MTSMC

Connections:
+5V: C5.1, C6.1, C10.1, C11.1, C12.1, C13.1, L1.2, U1.6 (Fdback), U2.1 (+Vs), U3.8 (VDD), U4.3 (VIN), U5.8 (VDD), U6.14 (VDD), U7.1, U7.31, U8.61 (VCC)
+12V: C1.1, C2.1, C3.1, K1.1, R1.1, U1.2 (In)
/SIG1: U5.7 (CLK), U7.3
/SIG2: U5.6 (DOUT), U7.4
/SIG3: U5.5 (~CS~/SHDN), U7.5
/SIG4: U6.11 (CLK), U7.6
/SIG5: U6.10 (DOUT), U7.7
/SIG6: U6.9 (DIN), U7.8
/SIG7: U6.8 (~CS~/SHDN), U7.9
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, D1.1 (A), J1.4 (GND), J1.5 (Shield_1), J1.6 (Shield_2), K1.2 (PM), K1.3, P1.2 (PM), P2.2 (PM), P3.2 (PM), R2.2, U1.4 (GND), U2.3 (GND), U3.3 (VINA+), U3.4 (VSS), U4.1 (VSS), U5.3 (IN-), U5.4 (VSS), U6.7 (DGND), U6.12 (AGND), U7.2, U7.29, U7.32, U7.34, U7.59, U8.26 (GND_2), U8.33 (RTS), U8.40 (DTR), U8.41 (GND_1), U8.63 (GND)
unnamed: C8.2, C9.1, U4.2 (VOUT), U5.1 (VREF), U6.13 (VREF)
unnamed: C4.2, D1.2 (K), L1.1, U1.1 (Out)
unnamed: C4.1, U1.3 (Cb)
unnamed: C7.2, R4.2, U3.1 (VOUTA), U5.2 (IN+)
unnamed: J1.2 (D-), U8.28 (USB_DN)
unnamed: J1.3 (D+), U8.27 (USB_DP)
unnamed: J1.1 (Vbus), U8.25 (USB_VBUS)
unnamed: U2.2 (Vout), U6.2 (CH1)
unnamed: P2.1, U6.4 (CH3)
unnamed: P1.1, U6.3 (CH2)
unnamed: U3.6 (VINB-), U3.7 (VOUTB), U6.1 (CH0)
unnamed: R1.2, R2.1, U3.5 (VINB+)
unnamed: C7.1, P3.1, R4.1, U3.2 (VINA-)
unnamed: U7.58, U8.24 (RESET)
unnamed: U7.35, U8.35 (TXD)
unnamed: U7.36, U8.34 (RXD)

Board: 2 copper layers, 132.1 x 82.5 mm, 35 parts (0 on the bottom side), 26 nets.

## Commit log

2017-02-10 add senosr hardware
2017-02-10 add readme
2017-02-10 add DOI badge
2017-02-10 remove svn that creeped in
